# Keil uVision project rp2021_plane_hal.uvprojx, settings and files
target rp2021_plane_hal (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: rp2021_plane_hal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;                                ../Drivers/STM32F4xx_HAL_Driver/Inc;                                ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                ../Middlewares/Third_Party/FreeRTOS/Source/include;                                ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                ../Drivers/CMSIS/Include;                                ..\Drivers\CMSIS\DSP\Include;                                ..\Application\DriverLayer;                                ..\Application\DeviceLayer\Imu\eMPL;                                ..\Application\DeviceLayer\Imu;                                ..\Application\DeviceLayer\Motor;                                ..\Application\DeviceLayer\Sensor;                                ..\Application\DeviceLayer;                                ..\Application\ModuleLayer;                                ..\Application\TaskLayer;                                ..\Application\AlgorithmLayer;                                ..\Application\ConfigLayer;                                ..\Application\PotocolLayer;                    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/Driver
    ../Application/DriverLayer/: drv_io.c drv_can.c drv_tim.c drv_uart.c drv_haltick.c driver.c
  group Application/Driver/Imu
    ../Application/DeviceLayer/Imu/: soft_iic.c bmi.c bmi2.c bmi2_common.c bmi2_ois.c bmi270.c bmi270_context.c
  group Application/Device
    ../Application/DeviceLayer/Sensor/: rc_sensor.c imu_sensor.c judge_sensor.c vision_sensor.c button_sensor.c
    ../Application/DeviceLayer/Motor/: gimbal_motor.c turnplate_motor.c fric_motor.c
    ../Application/DeviceLayer/: device.c
  group Application/Module
    ../Application/ModuleLayer/: vision.c gimbal.c turnplate.c fricwheel.c
  group Application/Task
    ../Application/TaskLayer/: system_task.c shoot_task.c gimbal_task.c monitor_task.c vision_task.c judge_task.c
  group Application/Algorithm
    ../Application/AlgorithmLayer/: pid.c crc.c kalman.c kalman_filter.c rp_math.c
  group Application/Config
    ../Application/ConfigLayer/: rp_config.h
  group Application/Potocol
    ../Application/PotocolLayer/: rc_potocol.c can_potocol.c imu_potocol.c pwm_potocol.c judge_potocol.c vision_potocol.c io_protocol.c a3_potocol.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dac.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c arm_mat_add_f32.c arm_mat_sub_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.4.0
