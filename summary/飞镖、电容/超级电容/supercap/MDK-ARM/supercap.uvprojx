# Keil uVision project supercap.uvprojx, settings and files
target supercap (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: supercap +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F334x8,__FPU_PRESENT = 1U,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP
  c include: ../Core/Inc;                                     ../Drivers/STM32F3xx_HAL_Driver/Inc;                                     ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                                     ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                                     ../Drivers/CMSIS/Include;                                     ..\User;           ../Middlewares/Third_Party/FreeRTOS/Source/include;           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c hrtim.c opamp.c tim.c usart.c stm32f3xx_it.c stm32f3xx_hal_msp.c stm32f3xx_hal_timebase_tim.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_can.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group User
    ../User/: cap.c oled.c kalman.c flash.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
